# Keil uVision project AltTorque.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F130G8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F130_serialServo +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\src\src_app;.\src\src_drv;.\src\src_main
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Objects\F130_serialServo.sct
  group src_main
    ./src/src_main/: main.c main.h
  group src_drv
    ./src/src_drv/: clk.c clk.h Systick_delay.c Systick_delay.h usart.c usart.h timer_pwm.c timer_pwm.h adc.c adc.h led_pwm.c led_pwm.h
  group src_app
    ./src/src_app/: app_gpio.h app_servo.c app_servo.h app_com.c app_com.h app_controlsys.c app_controlsys.h app_nvm.c app_nvm.h
software components: CMSIS:CORE 6.1.0, Device:GD32F1x0_StdPeripherals:MISC 3.2.0, Device:GD32F1x0_StdPeripherals:RCU 3.2.0, Device:GD32F1x0_libopt 3.2.0, Device:Startup 3.2.0
